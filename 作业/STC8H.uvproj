# Keil uVision project STC8H.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TLCD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: STC8H +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\DRIVER;.\STC8HLib
  group APP
    ./: STARTUP.A51
    ./APP/: main.c config.c StateMachine.c
  group DRIVER
    ./DRIVER/: BEEP.c KEY.c Digitalled.c encoder.c uart.c filtering.c IIC.c touch.c LCD_BASE.c LCD_DISPLAY.c Picture.c
  group STC8HLib
    ./STC8HLib/: STC8G_H_GPIO.c STC8G_H_Delay.c STC8G_H_Exti.c STC8G_H_NVIC.c STC8G_H_Exti_Isr.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c
    ../TEST/STC8HLib/: STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_ADC.c STC8G_H_ADC_Isr.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8H_RTC.c STC8H_RTC_Isr.c STC8G_H_SPI_Isr.c STC8G_H_SPI.c
