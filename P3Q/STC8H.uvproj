# Keil uVision project STC8H.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TLCD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: STC8H +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\STC8HLib;.\DRIVER
  group APP
    ./: STARTUP.A51
    ./APP/: main.c config.c
  group DRIVER
    ./DRIVER/: BEEP.c touch.c
  group STC8HLib
    ./STC8HLib/: STC8G_H_GPIO.c STC8G_H_Delay.c STC8G_H_Exti.c STC8G_H_Exti_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c
